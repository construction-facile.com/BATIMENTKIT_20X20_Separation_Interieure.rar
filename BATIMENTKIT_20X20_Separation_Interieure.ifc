Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcElementAssembly (747)
Name | PredefinedType | Poids Assemblage/Elément béton (kg) | Niveau Bas Assemblage/Elément béton | Niveau Haut Assemblage/Elément béton | Position maillage Assemblage/Elément béton | Repère Assemblage/Elément béton | Width (mm)
2 x Steel Assembly | RIGID_FRAME | 0.9 | +6.945 | +7.055 | 4/F | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 0.9 | +6.181 | +6.292 | 4/C | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 0.9 | +5.816 | +5.926 | 4/B | AT0(?) | 270.003
2 x Steel Assembly | RIGID_FRAME | 0.9 | +6.945 | +7.055 | 3/F | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 0.9 | +6.181 | +6.292 | 3/C | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 0.9 | +5.816 | +5.926 | 3/B | AT0(?) | 270.003
2 x Steel Assembly | RIGID_FRAME | 0.9 | +6.945 | +7.055 | 2/F | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 0.9 | +6.181 | +6.292 | 2/C | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 0.9 | +5.816 | +5.926 | 2/B | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 2.8 | +5.479 | +5.988 | 1/B | A0(?) | 100
Steel Assembly | RIGID_FRAME | 0.9 | +2.679 | +2.722 | 3/A | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 0.9 | +0.179 | +0.222 | 3/A | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 2.8 | +5.845 | +6.354 | 1/C | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +6.436 | +7.059 | 3/E-F | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.898 | +6.521 | 3/C-D | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +5.548 | +6.171 | 3/B-C | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.228 | +5.851 | 3/A-B | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.106 | +5.730 | 3/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +6.534 | +7.059 | 5/E-F | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.997 | +6.521 | 5/C-D | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.647 | +6.171 | 5/B-C | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.327 | +5.851 | 5/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.205 | +5.730 | 5/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +6.534 | +7.059 | 1/E-F | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.997 | +6.521 | 1/C-D | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.647 | +6.171 | 1/B-C | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.327 | +5.851 | 1/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.205 | +5.730 | 1/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 0.9 | +2.679 | +2.722 | 4/A | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 0.9 | +0.179 | +0.222 | 4/A | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 6.9 | +5.054 | +5.636 | 5/A | G0(?) | 4
Steel Assembly | RIGID_FRAME | 6.9 | +5.054 | +5.636 | 1/A | G0(?) | 4
Steel Assembly | RIGID_FRAME | 28.3 | +6.504 | +6.717 | 3-4/D | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 28.3 | +6.126 | +6.339 | 3-4/C | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 28.3 | +5.760 | +5.973 | 3-4/B | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 28.3 | +5.383 | +5.596 | 3-4/A | PA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 1.3 | +6.905 | +7.109 | 1/F | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 27.7 | +6.504 | +6.717 | 1-2/D | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.7 | +6.126 | +6.339 | 1-2/C | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.7 | +5.760 | +5.973 | 1-2/B | PA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 1.3 | +5.398 | +5.603 | 2/A | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 27.7 | +5.383 | +5.596 | 1-2/A | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +5.398 | +5.603 | 1/A | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 27.1 | +6.126 | +6.339 | 2-3/C | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +5.760 | +5.973 | 2-3/B | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +6.504 | +6.717 | 2-3/D | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +5.383 | +5.596 | 2-3/A | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +6.126 | +6.339 | 4-5/C | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +5.760 | +5.973 | 4-5/B | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +6.504 | +6.717 | 4-5/D | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +5.383 | +5.596 | 4-5/A | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 23.4 | +4.704 | +5.698 | 2/K-L | G0(?) | 4
Steel Assembly | RIGID_FRAME | 23.4 | +4.704 | +5.698 | 4/K-L | G0(?) | 4
2 x Steel Assembly | RIGID_FRAME | 4.5 | +5.926 | +6.732 | 4/H | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +5.926 | +6.732 | 2/H | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +5.548 | +6.354 | 4/I | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +5.182 | +5.988 | 4/K | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +5.548 | +6.354 | 2/I | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +5.182 | +5.988 | 2/K | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +5.350 | +6.171 | 4/I-K | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +6.238 | +7.059 | 4/F-G | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +5.700 | +6.521 | 4/H-I | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +5.030 | +5.851 | 4/K-L | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +4.909 | +5.730 | 4/K-L | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +6.238 | +7.059 | 2/F-G | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +5.700 | +6.521 | 2/H-I | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +5.030 | +5.851 | 2/K-L | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +4.909 | +5.730 | 2/K-L | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 4.5 | +5.350 | +6.171 | 2/I-K | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +6.223 | +6.732 | 5/H | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +6.124 | +6.732 | 3/H | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +6.223 | +6.732 | 1/H | A0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +1.179 | +1.379 | 1/K-L | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +3.579 | +3.779 | 1/K-L | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +2.579 | +2.679 | 2/K-L | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +0.079 | +0.179 | 2/K-L | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 4.5 | +1.179 | +1.379 | 2/K-L | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 4.5 | +3.579 | +3.779 | 2/K-L | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 0.9 | +2.679 | +2.722 | 2/L | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 0.9 | +0.179 | +0.222 | 2/L | AT0(?) | 270.003
2 x Steel Assembly | RIGID_FRAME | 4.5 | +2.579 | +2.679 | 4/K-L | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +0.079 | +0.179 | 4/K-L | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 4.5 | +4.679 | +4.879 | 4/K-L | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 4.5 | +1.179 | +1.379 | 4/K-L | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 4.5 | +3.579 | +3.779 | 4/K-L | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +1.179 | +1.379 | 5/K-L | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +3.579 | +3.779 | 5/K-L | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +2.632 | +2.679 | 5/A | AT0(?) | 170.003
Steel Assembly | RIGID_FRAME | 1.3 | +0.132 | +0.179 | 5/A | AT0(?) | 170.003
Steel Assembly | RIGID_FRAME | 2.8 | +5.479 | +5.988 | 5/K | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.845 | +6.354 | 5/I | A0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +5.398 | +5.603 | 5/L | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 1.3 | +5.398 | +5.603 | 4/L | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 1.3 | +5.398 | +5.603 | 3/L | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.746 | +6.354 | 3/I | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.380 | +5.988 | 3/K | A0(?) | 100
Steel Assembly | RIGID_FRAME | 0.9 | +5.438 | +5.549 | 4/L | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 0.9 | +5.438 | +5.549 | 3/L | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 0.9 | +5.438 | +5.549 | 2/L | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 0.9 | +6.181 | +6.292 | 4/I | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 0.9 | +5.816 | +5.926 | 4/K | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 0.9 | +6.181 | +6.292 | 3/I | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 0.9 | +5.816 | +5.926 | 3/K | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 0.9 | +6.181 | +6.292 | 2/I | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 0.9 | +5.816 | +5.926 | 2/K | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 2.8 | +5.479 | +5.988 | 1/K | A0(?) | 100
Steel Assembly | RIGID_FRAME | 0.9 | +2.679 | +2.722 | 3/L | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 0.9 | +0.179 | +0.222 | 3/L | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 2.1 | +6.275 | +6.498 | 5/H | G0(?) | 4
Steel Assembly | RIGID_FRAME | 2.8 | +6.162 | +6.671 | 5/H | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.845 | +6.354 | 1/I | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +6.436 | +7.059 | 3/F-G | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.898 | +6.521 | 3/H-I | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +5.548 | +6.171 | 3/I-K | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.228 | +5.851 | 3/K-L | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.106 | +5.730 | 3/K-L | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +6.534 | +7.059 | 5/F-G | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.997 | +6.521 | 5/H-I | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.647 | +6.171 | 5/I-K | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.327 | +5.851 | 5/K-L | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.205 | +5.730 | 5/K-L | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +6.534 | +7.059 | 1/F-G | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.997 | +6.521 | 1/H-I | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.647 | +6.171 | 1/I-K | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.327 | +5.851 | 1/K-L | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.205 | +5.730 | 1/K-L | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 0.9 | +2.679 | +2.722 | 4/L | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 0.9 | +0.179 | +0.222 | 4/L | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1.3 | +2.632 | +2.679 | 1/A | AT0(?) | 170.003
Steel Assembly | RIGID_FRAME | 1.3 | +0.132 | +0.179 | 1/A | AT0(?) | 170.003
Steel Assembly | RIGID_FRAME | 6.9 | +5.054 | +5.636 | 5/L | G0(?) | 4
Steel Assembly | RIGID_FRAME | 6.9 | +5.054 | +5.636 | 1/L | G0(?) | 4
2 x Steel Assembly | RIGID_FRAME | 1.3 | +5.209 | +5.256 | 3/A | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 1.3 | +5.209 | +5.256 | 4/A | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 28.3 | +5.256 | +5.356 | 3-4/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 28.3 | +2.679 | +2.779 | 3-4/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 28.3 | +0.179 | +0.279 | 3-4/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 28.3 | +6.504 | +6.717 | 3-4/H | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 28.3 | +6.126 | +6.339 | 3-4/I | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 28.3 | +5.760 | +5.973 | 3-4/K | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 28.3 | +5.383 | +5.596 | 3-4/L | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.7 | +6.504 | +6.717 | 1-2/H | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.7 | +6.126 | +6.339 | 1-2/I | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.7 | +5.760 | +5.973 | 1-2/K | PA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 1.3 | +5.398 | +5.603 | 2/L | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 27.7 | +5.383 | +5.596 | 1-2/L | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +5.398 | +5.603 | 1/L | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +5.209 | +5.256 | 1/A | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 1.3 | +5.209 | +5.256 | 2/A | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 27.7 | +5.256 | +5.356 | 1-2/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.7 | +2.679 | +2.779 | 1-2/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.7 | +0.179 | +0.279 | 1-2/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.9 | +0.000 | +0.054 | 2/A | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 27.1 | +6.126 | +6.339 | 2-3/I | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +5.760 | +5.973 | 2-3/K | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +6.504 | +6.717 | 2-3/H | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +5.383 | +5.596 | 2-3/L | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +0.179 | +0.279 | 2-3/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +2.679 | +2.779 | 2-3/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +5.256 | +5.356 | 2-3/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.9 | +0.000 | +0.054 | 4/A | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 27.1 | +6.126 | +6.339 | 4-5/I | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +5.760 | +5.973 | 4-5/K | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +6.504 | +6.717 | 4-5/H | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +5.383 | +5.596 | 4-5/L | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +5.209 | +5.256 | 5/A | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 27.1 | +0.179 | +0.279 | 4-5/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +2.679 | +2.779 | 4-5/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +5.256 | +5.356 | 4-5/A | LS0(?) | 100

# IfcFooting: 1200*1000 (10)
In: Undefined
Description: 1200*1000; Material: MISCELLANEOUS/VERRE
Tekla Commun - Niveau bas: -1.000; Niveau haut: -0.000; Repère de pièce: S0(?); Repère d'assemblage: S0(?); Phase: 255; Classe: 8; Matériau: VERRE; Profil: 1200*1000; Nom: SEMELLE
Tekla Quantités - Poids: 3036 kg; Volume: 1.2 m3; Surface supérieure totale: 1.2 m2; Surface par tonne: 2.2 m2; Surface nette: 6.8 m2; Hauteur: 1200 mm; Largeur: 1000 mm; Longueur: 1000 mm
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 6.8 m2; GrossSurfaceArea: 6.8 m2; CrossSectionArea: 1.2 m2; NetVolume: 1.2 m3; GrossVolume: 1.2 m3; NetWeight: 3036 kg; GrossWeight: 3036 kg; Width: 1000 mm; Height: 1200 mm

# IfcFooting: 275*275 (4)
In: Undefined
Description: 275*275; Material: MISCELLANEOUS/VERRE
Tekla Commun - Niveau bas: -0.475; Niveau haut: -0.025; Repère de pièce: S0(?); Repère d'assemblage: S0(?); Phase: 241; Classe: 8; Matériau: VERRE; Profil: 275*275; Nom: SEMELLE
Tekla Quantités - Poids: 86.1 kg; Volume: 0 m3; Surface supérieure totale: 0.1 m2; Surface par tonne: 7.5 m2; Surface nette: 0.7 m2; Hauteur: 275 mm; Largeur: 275 mm; Longueur: 450 mm
BaseQuantities - Length: 450 mm; OuterSurfaceArea: 0.64625 m2; GrossSurfaceArea: 0.64625 m2; CrossSectionArea: 0.075625 m2; NetVolume: 0.0340312 m3; GrossVolume: 0.0340312 m3; NetWeight: 86.0991 kg; GrossWeight: 86.0991 kg; Width: 275 mm; Height: 275 mm

# IfcFooting: 800*800 (4)
In: Undefined
Description: 800*800; Material: MISCELLANEOUS/VERRE
Tekla Commun - Niveau bas: -0.825; Niveau haut: -0.025; Repère de pièce: S0(?); Repère d'assemblage: S0(?); Phase: 241; Classe: 8; Matériau: VERRE; Profil: 800*800; Nom: SEMELLE
Tekla Quantités - Poids: 1295.4 kg; Volume: 0.5 m3; Surface supérieure totale: 0.6 m2; Surface par tonne: 3 m2; Surface nette: 3.8 m2; Hauteur: 800 mm; Largeur: 800 mm; Longueur: 800 mm
BaseQuantities - Length: 800 mm; OuterSurfaceArea: 3.84 m2; GrossSurfaceArea: 3.84 m2; CrossSectionArea: 0.64 m2; NetVolume: 0.512 m3; GrossVolume: 0.512 m3; NetWeight: 1295.36 kg; GrossWeight: 1295.36 kg; Width: 800 mm; Height: 800 mm

# IfcFooting: 850*130 (10)
In: Undefined
Description: 850*130; Material: MISCELLANEOUS/VERRE
Tekla Commun - Niveau bas: -0.650; Niveau haut: -0.000; Repère de pièce: S0(?); Repère d'assemblage: S0(?); Phase: 255; Classe: 8; Matériau: VERRE; Profil: 850*130; Nom: SEMELLE
Tekla Quantités - Poids: 181.7 kg; Volume: 0.1 m3; Surface supérieure totale: 0.1 m2; Surface par tonne: 8.2 m2; Surface nette: 1.5 m2; Hauteur: 850 mm; Largeur: 130 mm; Longueur: 650 mm
BaseQuantities - Length: 650 mm; OuterSurfaceArea: 1.495 m2; GrossSurfaceArea: 1.495 m2; CrossSectionArea: 0.1105 m2; NetVolume: 0.071825 m3; GrossVolume: 0.071825 m3; NetWeight: 181.717 kg; GrossWeight: 181.717 kg; Width: 130 mm; Height: 850 mm

# IfcMechanicalFastener: Bolt assembly (15583)
In: Undefined
Material: 8.8
Tekla Boulons - Type rondelle: PLA-8.8; Type écrou: E-8.8; Trou oblong Y: 0 mm; Trou oblong X: 0 mm; Lieu Boulonnage: Montage; Standard: 8.8
Name | NominalDiameter (mm) = Diamètre rondelle (mm) = Diamètre (mm) | NominalLength (mm) | Quantité de rondelle | Nom rondelle | Quantité d'écrou | Nom écrou | Diamètre du trou (mm) | Quantité | Longueur (mm) | Nom
788 x Bolt assembly | 12 | 25 | 0 | RONDELLE-M12-PLA-8.8 | 1 | ECROU-M12-E-8.8 | 14 | 1 | 25 | M12*25
2092 x Bolt assembly | 12 | 1.5 | 0 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 1 | 1.5 | M12*25
169 x Bolt assembly | 12 | 25 | 0 | RONDELLE-M12-PLA-8.8 | 4 | ECROU-M12-E-8.8 | 14 | 4 | 25 | M12*25
8706 x Bolt assembly | 12 | 2 | 0 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 2 | 2 | M12*25
2194 x Bolt assembly | 12 | 25 | 0 | RONDELLE-M12-PLA-8.8 | 2 | ECROU-M12-E-8.8 | 14 | 2 | 25 | M12*25
156 x Bolt assembly | 12 | 4 | 0 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 2 | 4 | M12*25
453 x Bolt assembly | 12 | 2 | 0 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 1 | 2 | M12*25
882 x Bolt assembly | 12 | 1.5 | 0 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 2 | 1.5 | M12*25
34 x Bolt assembly | 12 | 4.00002 | 0 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 2 | 4 | M12*25
12 x Bolt assembly | 24 | 4 | 0 | RONDELLE-M24-PLA-8.8 | 0 | ECROU-M24-E-8.8 | 26 | 1 | 4 | M24*50
8 x Bolt assembly | 12 | 25 | 0 | RONDELLE-M12-PLA-8.8 | 8 | ECROU-M12-E-8.8 | 14 | 8 | 25 | M12*25
34 x Bolt assembly | 12 | 1.49976 | 0 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 1 | 1.5 | M12*25
16 x Bolt assembly | 12 | 3.93 | 0 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 1 | 4 | M12*25
8 x Bolt assembly | 12 | 4 | 0 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 1 | 4 | M12*25
27 x Bolt assembly | 12 | 4 | 0 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 4 | 4 | M12*25
4 x Bolt assembly | 12 | 25 | 4 | RONDELLE-M12-PLA-8.8 | 4 | ECROU-M12-E-8.8 | 14 | 4 | 25 | M12*25

# IfcMember: SADEF-C+200X1.50 (134)
In: Undefined
Description: SADEF-C+200X1.50
Tekla Commun - Profil: SADEF-C+200X1.50
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 151.5 m2; Hauteur: 200 mm; Largeur: 100 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.000723 m2
Name | Material | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Phase | Classe | Matériau | Nom | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
2 x ARBA | STEEL/Steel_Undefined | +0.255 | +2.695 | A0(?) | 245 | 6 | Steel_Undefined | ARBA | 18.7 | 3.3 | 3300.1 | 3300.05 | 2.83804 | 0.00249484 | 0.00238594 | 19.5845 | 18.7296
2 x ARBA | STEEL/Steel_Undefined | +2.712 | +5.146 | A0(?) | 245 | 6 | Steel_Undefined | ARBA | 18.7 | 3.3 | 3291.4 | 3291.43 | 2.83063 | 0.00248832 | 0.0023797 | 19.5333 | 18.6806
2 x ARBA | STEEL/Steel_Undefined | +0.255 | +5.146 | A0(?) | 245 | 6 | Steel_Undefined | ARBA | 38.1 | 6.8 | 6711.5 | 6711.53 | 5.77191 | 0.00507391 | 0.00485243 | 39.8302 | 38.0916
4 x POUTRE | STEEL/S235JR | +6.162 | +6.671 | A0(?) | 63 | 99 | S235JR | POUTRE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
4 x POUTRE | STEEL/S235JR | +6.223 | +6.732 | A0(?) | 63 | 99 | S235JR | POUTRE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
8 x POUTRE | STEEL/S235JR | +5.926 | +6.732 | A0(?) | 62 | 99 | S235JR | POUTRE | 4.5 | 0.7 | 800 | 800 | 0.688 | 0.0006048 | 0.0005784 | 4.74768 | 4.54044
4 x POUTRE | STEEL/S235JR | +6.124 | +6.732 | A0(?) | 62 | 99 | S235JR | POUTRE | 3.4 | 0.7 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
4 x POUTRE | STEEL/S235JR | +5.479 | +5.988 | A0(?) | 63 | 99 | S235JR | POUTRE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
4 x POUTRE | STEEL/S235JR | +5.845 | +6.354 | A0(?) | 63 | 99 | S235JR | POUTRE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
8 x POUTRE | STEEL/S235JR | +5.548 | +6.354 | A0(?) | 62 | 99 | S235JR | POUTRE | 4.5 | 0.7 | 800 | 800 | 0.688 | 0.0006048 | 0.0005784 | 4.74768 | 4.54044
8 x POUTRE | STEEL/S235JR | +5.182 | +5.988 | A0(?) | 62 | 99 | S235JR | POUTRE | 4.5 | 0.7 | 800 | 800 | 0.688 | 0.0006048 | 0.0005784 | 4.74768 | 4.54044
4 x POUTRE | STEEL/S235JR | +5.746 | +6.354 | A0(?) | 62 | 99 | S235JR | POUTRE | 3.4 | 0.7 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
4 x POUTRE | STEEL/S235JR | +5.380 | +5.988 | A0(?) | 62 | 99 | S235JR | POUTRE | 3.4 | 0.7 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
6 x RENFORT-ATTACHE | STEEL/S235JR | +5.350 | +6.171 | RA0(?) | 62 | 99 | S235JR | RENFORT-ATTACHE | 4.5 | 0.7 | 800 | 800 | 0.688 | 0.0006048 | 0.0005784 | 4.74768 | 4.54044
8 x RENFORT-ATTACHE | STEEL/S235JR | +6.238 | +7.059 | RA0(?) | 62 | 99 | S235JR | RENFORT-ATTACHE | 4.5 | 0.7 | 800 | 800 | 0.688 | 0.0006048 | 0.0005784 | 4.74768 | 4.54044
8 x RENFORT-ATTACHE | STEEL/S235JR | +5.700 | +6.521 | RA0(?) | 62 | 99 | S235JR | RENFORT-ATTACHE | 4.5 | 0.7 | 800 | 800 | 0.688 | 0.0006048 | 0.0005784 | 4.74768 | 4.54044
8 x RENFORT-ATTACHE | STEEL/S235JR | +5.030 | +5.851 | RA0(?) | 62 | 99 | S235JR | RENFORT-ATTACHE | 4.5 | 0.7 | 800 | 800 | 0.688 | 0.0006048 | 0.0005784 | 4.74768 | 4.54044
8 x RENFORT-ATTACHE | STEEL/S235JR | +4.909 | +5.730 | RA0(?) | 62 | 99 | S235JR | RENFORT-ATTACHE | 4.5 | 0.7 | 800 | 800 | 0.688 | 0.0006048 | 0.0005784 | 4.74768 | 4.54044
4 x RENFORT-ATTACHE | STEEL/S235JR | +6.436 | +7.059 | RA0(?) | 62 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.7 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
4 x RENFORT-ATTACHE | STEEL/S235JR | +5.898 | +6.521 | RA0(?) | 62 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.7 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
2 x RENFORT-ATTACHE | STEEL/S235JR | +5.548 | +6.171 | RA0(?) | 62 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.7 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
4 x RENFORT-ATTACHE | STEEL/S235JR | +5.228 | +5.851 | RA0(?) | 62 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.7 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
4 x RENFORT-ATTACHE | STEEL/S235JR | +5.106 | +5.730 | RA0(?) | 62 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.7 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
4 x RENFORT-ATTACHE | STEEL/S235JR | +6.534 | +7.059 | RA0(?) | 63 | 99 | S235JR | RENFORT-ATTACHE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
4 x RENFORT-ATTACHE | STEEL/S235JR | +5.997 | +6.521 | RA0(?) | 63 | 99 | S235JR | RENFORT-ATTACHE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
4 x RENFORT-ATTACHE | STEEL/S235JR | +5.647 | +6.171 | RA0(?) | 63 | 99 | S235JR | RENFORT-ATTACHE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
4 x RENFORT-ATTACHE | STEEL/S235JR | +5.327 | +5.851 | RA0(?) | 63 | 99 | S235JR | RENFORT-ATTACHE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
4 x RENFORT-ATTACHE | STEEL/S235JR | +5.205 | +5.730 | RA0(?) | 63 | 99 | S235JR | RENFORT-ATTACHE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777

# IfcPlate: PL2*100 (16)
In: Undefined
Description: PL2*100; Material: STEEL/S235JR
Pset_PlateCommon - LoadBearing: yes; Reference: PLA0(?)
Tekla Commun - Repère de pièce: PLA0(?); Repère d'assemblage: PLA0(?); Phase: 247; Classe: 99; Matériau: S235JR; Profil: PL2*100; Nom: PLAT
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 100 mm; Largeur: 2 mm
BaseQuantities - Width: 100 mm; CrossSectionArea: 0.000004 m2
Name | Niveau bas | Niveau haut | Poids (kg) | Surface par tonne (m2) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x PLAT | +4.856 | +4.956 | 0.5 | 130.8 | 300 | 0.0616 | 0.03 | 0.00006
4 x PLAT | +4.856 | +4.956 | 0.6 | 130.6 | 400 | 0.082 | 0.04 | 0.00008
4 x PLAT | +0.179 | +0.279 | 0.6 | 130.6 | 400 | 0.082 | 0.04 | 0.00008
4 x PLAT | +2.679 | +2.779 | 0.6 | 130.6 | 400 | 0.082 | 0.04 | 0.00008

# IfcPlate: PL2*140 (8)
In: Undefined
Description: PL2*140; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: PLA0(?); Repère d'assemblage: PLA0(?); Phase: 247; Classe: 99; Matériau: S235JR; Profil: PL2*140; Nom: PLAT
Tekla Quantités - Poids: 0.9 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 129.8 m2; Surface nette: 0.1 m2; Hauteur: 140 mm; Largeur: 2 mm; Longueur: 400 mm
Pset_PlateCommon - LoadBearing: yes; Reference: PLA0(?)
BaseQuantities - Width: 140 mm; NetArea: 0.11416 m2; GrossArea: 0.056 m2; CrossSectionArea: 0.000004 m2; NetVolume: 0.000112 m3; GrossVolume: 0.000112 m3
Name | Niveau bas | Niveau haut
4 x PLAT | +1.209 | +1.349
4 x PLAT | +3.709 | +3.849

# IfcPlate: PL4*100 (16)
In: Undefined
Description: PL4*100; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: PL0(?); Repère d'assemblage: PL0(?); Classe: 99; Matériau: S235JR; Profil: PL4*100; Nom: PLAT
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 66.8 m2; Surface nette: 0.1 m2; Hauteur: 100 mm; Largeur: 4 mm
Pset_PlateCommon - LoadBearing: yes; Reference: PL0(?)
BaseQuantities - Width: 100 mm; CrossSectionArea: 0.000016 m2
Name | Niveau bas | Niveau haut | Phase | Poids (kg) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x PLAT | +2.518 | +2.889 | 245 | 1.3 | 420 | 0.0881704 | 0.042005 | 0.00016802
2 x PLAT | +6.690 | +6.738 | 246 | 1.5 | 470 | 0.0985704 | 0.047005 | 0.00018802
2 x PLAT | +6.488 | +6.536 | 246 | 1.5 | 470 | 0.0985704 | 0.047005 | 0.00018802
2 x PLAT | +5.458 | +5.517 | 246 | 1.5 | 470 | 0.0985704 | 0.047005 | 0.00018802
2 x PLAT | +5.660 | +5.719 | 246 | 1.5 | 470 | 0.0985704 | 0.047005 | 0.00018802
2 x PLAT | +5.999 | +6.058 | 246 | 1.5 | 470 | 0.0985704 | 0.047005 | 0.00018802
2 x PLAT | +6.201 | +6.260 | 246 | 1.5 | 470 | 0.0985704 | 0.047005 | 0.00018802

# IfcPlate: PL4*162 (4)
In: Undefined
Description: PL4*162; Material: STEEL/S235JR
Pset_PlateCommon - LoadBearing: yes; Reference: G0(?)
Tekla Commun - Niveau bas: +6.275; Niveau haut: +6.498; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Phase: 63; Classe: 99; Matériau: S235JR; Profil: PL4*162; Nom: GOUSSET
Tekla Quantités - Poids: 2.1 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 65.9 m2; Surface nette: 0.1 m2; Hauteur: 161.8 mm; Largeur: 4 mm; Longueur: 418.2 mm
BaseQuantities - Width: 161.79 mm; NetArea: 0.139971 m2; GrossArea: 0.0676654 m2; CrossSectionArea: 0.000016 m2; NetVolume: 0.000270662 m3; GrossVolume: 0.000270662 m3

# IfcPlate: PL4*400 (6)
In: Undefined
Description: PL4*400; Material: STEEL/S235JR
Pset_PlateCommon - LoadBearing: yes; Reference: G0(?)
Tekla Commun - Niveau bas: +5.054; Niveau haut: +5.636; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Classe: 99; Matériau: S235JR; Profil: PL4*400; Nom: GOUSSET
Tekla Quantités - Poids: 6.9 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64.8 m2; Surface nette: 0.4 m2; Hauteur: 400.2 mm; Largeur: 4 mm; Longueur: 582 mm
BaseQuantities - Width: 400.158 mm; NetArea: 0.448656 m2; GrossArea: 0.232894 m2; CrossSectionArea: 0.000016 m2; NetVolume: 0.000882055 m3; GrossVolume: 0.000882055 m3
Name | Phase
4 x GOUSSET | 60
2 x GOUSSET | 59

# IfcPlate: PL4*450 (3)
In: Undefined
Description: PL4*450; Material: STEEL/S235JR
Pset_PlateCommon - LoadBearing: yes; Reference: G0(?)
Tekla Commun - Niveau bas: +6.665; Niveau haut: +7.115; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Classe: 99; Matériau: S235JR; Profil: PL4*450; Nom: GOUSSET
Tekla Quantités - Poids: 8.3 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64.8 m2; Surface nette: 0.4 m2; Hauteur: 450.1 mm; Largeur: 4 mm; Longueur: 682.4 mm
BaseQuantities - Width: 450.149 mm; NetArea: 0.537583 m2; GrossArea: 0.307168 m2; CrossSectionArea: 0.000016 m2; NetVolume: 0.00105873 m3; GrossVolume: 0.00105873 m3
Name | Phase
2 x GOUSSET | 60
GOUSSET | 59

# IfcPlate: PL4*674 (2)
In: Undefined
Description: PL4*674; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +6.272; Niveau haut: +7.115; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Phase: 64; Classe: 99; Matériau: S235JR; Profil: PL4*674; Nom: GOUSSET
Tekla Quantités - Poids: 14.5 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64.4 m2; Surface nette: 0.9 m2; Hauteur: 674.4 mm; Largeur: 4 mm; Longueur: 866.8 mm
Pset_PlateCommon - LoadBearing: yes; Reference: G0(?)
BaseQuantities - Width: 674.407 mm; NetArea: 0.933163 m2; GrossArea: 0.584587 m2; CrossSectionArea: 0.000016 m2; NetVolume: 0.00184449 m3; GrossVolume: 0.00184449 m3

# IfcPlate: PL4*801 (4)
In: Undefined
Description: PL4*801; Material: STEEL/S235JR
Pset_PlateCommon - LoadBearing: yes; Reference: G0(?)
Tekla Commun - Niveau bas: +4.704; Niveau haut: +5.698; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Classe: 99; Matériau: S235JR; Profil: PL4*801; Nom: GOUSSET
Tekla Quantités - Poids: 23.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64.3 m2; Surface nette: 1.5 m2; Hauteur: 801 mm; Largeur: 4 mm; Longueur: 994.6 mm
BaseQuantities - Width: 800.996 mm; NetArea: 1.50619 m2; GrossArea: 0.796643 m2; CrossSectionArea: 0.000016 m2; NetVolume: 0.00298459 m3; GrossVolume: 0.00298459 m3
Name | Phase
2 x GOUSSET | 56
2 x GOUSSET | 58
