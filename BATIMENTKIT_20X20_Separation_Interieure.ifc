Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: Tekla.ifc
Time: 2022-11-10T18:30:07
Author: RV-PC\W77
Organization: Structural Designer
Written by: IFC Database version:Work
Made in: Tekla Structures 21.1, IFC Export Version: 4.0.0.0 Sep 11 2015

# IfcSite, Undefined
RefElevation: 0 mm

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: PL2*100 (8)
In: Undefined
Description: PL2*100; Material: STEEL/Steel_Undefined
Tekla Commun - Repère de pièce: An0(?); Repère d'assemblage: An0(?); Phase: 247; Classe: 7; Matériau: Steel_Undefined; Profil: PL2*100; Nom: Angle
Tekla Quantités - Poids: 0.9 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 130.4 m2; Surface nette: 0.1 m2; Hauteur: 100 mm; Largeur: 2 mm; Longueur: 548 mm
Pset_BeamCommon - LoadBearing: yes; Reference: An0(?)
BaseQuantities - Length: 548 mm; OuterSurfaceArea: 0.1126 m2; NetVolume: 0.00011 m3; NetWeight: 0.8635 kg
Name | Niveau bas | Niveau haut
4 x Angle | +2.679 | +2.779
4 x Angle | +0.179 | +0.279

# IfcBeam: PL4*105 (48)
In: Undefined
Description: PL4*105; Material: STEEL/S235JR
Pset_BeamCommon - LoadBearing: yes; Reference: AT0(?)
Tekla Commun - Repère de pièce: AT0(?); Repère d'assemblage: AT0(?); Classe: 3; Matériau: S235JR; Profil: PL4*105; Nom: ATTACHE
Tekla Quantités - Poids: 0.9 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 66.9 m2; Surface nette: 0.1 m2; Hauteur: 105 mm; Largeur: 4 mm; Longueur: 305 mm
BaseQuantities - Length: 305.003 mm; OuterSurfaceArea: 0.0682027 m2; NetVolume: 0.000129781 m3; NetWeight: 1.01878 kg
Name | Niveau bas | Niveau haut | Phase
12 x ATTACHE | +6.559 | +6.670 | 61
6 x ATTACHE | +2.679 | +2.722 | 1
6 x ATTACHE | +0.179 | +0.222 | 1
2 x ATTACHE | +5.438 | +5.549 | 58
2 x ATTACHE | +5.438 | +5.549 | 57
2 x ATTACHE | +5.438 | +5.549 | 56
2 x ATTACHE | +6.945 | +7.055 | 58
2 x ATTACHE | +6.181 | +6.292 | 58
2 x ATTACHE | +5.816 | +5.926 | 58
2 x ATTACHE | +6.945 | +7.055 | 57
2 x ATTACHE | +6.181 | +6.292 | 57
2 x ATTACHE | +5.816 | +5.926 | 57
2 x ATTACHE | +6.945 | +7.055 | 56
2 x ATTACHE | +6.181 | +6.292 | 56
2 x ATTACHE | +5.816 | +5.926 | 56

# IfcBeam: PL4*150 (24)
In: Undefined
Description: PL4*150; Material: STEEL/Steel_Undefined
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Matériau: Steel_Undefined; Profil: PL4*150; Nom: AT CROIX
Tekla Quantités - Poids: 2.9 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 65.8 m2; Surface nette: 0.2 m2; Hauteur: 150 mm; Largeur: 4 mm; Longueur: 602 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A0(?)
BaseQuantities - Length: 602 mm; OuterSurfaceArea: 0.18908 m2; NetVolume: 0.000366 m3; NetWeight: 2.8731 kg
Name | Niveau bas | Niveau haut | Phase | Classe
4 x AT CROIX | +4.953 | +5.103 | 245 | 99
4 x AT CROIX | +0.304 | +0.454 | 245 | 99
4 x AT CROIX | +6.332 | +6.563 | 246 | 6
4 x AT CROIX | +6.662 | +6.893 | 246 | 6
4 x AT CROIX | +5.211 | +5.442 | 246 | 6
4 x AT CROIX | +6.277 | +6.508 | 246 | 6

# IfcBeam: PL4*180 (6)
In: Undefined
Description: PL4*180; Material: STEEL/S235JR
Pset_BeamCommon - LoadBearing: yes
Tekla Commun - Phase: 258; Classe: 99; Matériau: S235JR; Profil: PL4*180
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 180 mm; Largeur: 4 mm
Name | Reference = Repère de pièce = Repère d'assemblage | Niveau bas | Niveau haut | Nom | Poids (kg) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x PLATINE | PL0(?) | +0.000 | +0.102 | PLATINE | 0.9 | 66.6 | 0.1 | 166 | 166 | 0.064 | 0.0001224 | 0.96084
2 x ATTACHE | AT0(?) | +6.142 | +6.243 | ATTACHE | 0.6 | 67.1 | 0 | 121.6 | 121.569 | 0.04744 | 0.00009 | 0.7065

# IfcBeam: PL4*200 (130)
In: Undefined
Description: PL4*200; Material: STEEL/S235JR
Tekla Commun - Classe: 99; Matériau: S235JR; Profil: PL4*200
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 200 mm; Largeur: 4 mm
Pset_BeamCommon - LoadBearing: yes
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Phase | Nom | Poids (kg) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x PLATINE | +1.154 | +1.206 | PL0(?) | 252 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
4 x PLATINE | +2.053 | +2.105 | PL0(?) | 252 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
8 x PLATINE | +2.063 | +2.105 | PL0(?) | 252 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
4 x PLATINE | +1.012 | +1.054 | PL0(?) | 252 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
4 x PLATINE | +0.137 | +0.179 | PL0(?) | 252 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
2 x ATTACHE | +2.889 | +2.936 | AT0(?) | 252 | ATTACHE | 1.3 | 66.2 | 0.1 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
4 x PLATINE | +2.637 | +2.679 | PL0(?) | 252 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
2 x PLATINE | +0.000 | +0.102 | PL0(?) | 252 | PLATINE | 0.9 | 66.8 | 0.1 | 146 | 146 | 0.0628 | 0.00012 | 0.942
2 x ATTACHE | +0.132 | +0.179 | AT0(?) | 252 | ATTACHE | 1.3 | 66.2 | 0.1 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
2 x ATTACHE | +2.632 | +2.679 | AT0(?) | 252 | ATTACHE | 1.3 | 66.2 | 0.1 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
6 x ATTACHE | +0.132 | +0.179 | AT0(?) | 258 | ATTACHE | 1.3 | 66.2 | 0.1 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
6 x ATTACHE | +2.634 | +2.681 | AT0(?) | 258 | ATTACHE | 1.3 | 66.2 | 0.1 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
6 x ATTACHE | +4.709 | +4.756 | AT0(?) | 258 | ATTACHE | 1.3 | 66.2 | 0.1 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
2 x PLATINE | +0.000 | +0.102 | PL0(?) | 252 | PLATINE | 0.9 | 66.6 | 0.1 | 146 | 146 | 0.0628 | 0.00012 | 0.942
4 x PLATINE | +0.137 | +0.179 | PL0(?) | 249 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
4 x PLATINE | +2.637 | +2.679 | PL0(?) | 249 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
4 x PLATINE | +2.958 | +3.000 | PL0(?) | 249 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
4 x PLATINE | +0.000 | +0.102 | PL0(?) | 249 | PLATINE | 0.9 | 66.6 | 0.1 | 146 | 146 | 0.0628 | 0.00012 | 0.942
2 x ATTACHE | +0.132 | +0.179 | AT0(?) | 248 | ATTACHE | 1.3 | 66.2 | 0.1 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
2 x ATTACHE | +2.632 | +2.679 | AT0(?) | 248 | ATTACHE | 1.3 | 66.2 | 0.1 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
4 x ATTACHE | +4.809 | +4.856 | AT0(?) | 248 | ATTACHE | 1.3 | 66.2 | 0.1 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
4 x ATTACHE | +2.632 | +2.679 | AT0(?) | 65 | ATTACHE | 1.3 | 66.2 | 0.1 | 209 | 209.003 | 0.0885053 | 0.000170403 | 1.33766
4 x ATTACHE | +0.132 | +0.179 | AT0(?) | 65 | ATTACHE | 1.3 | 66.2 | 0.1 | 209 | 209.003 | 0.0885053 | 0.000170403 | 1.33766
16 x ATTACHE | +5.209 | +5.256 | AT0(?) | 65 | ATTACHE | 1.3 | 66.2 | 0.1 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
6 x ATTACHE | +6.905 | +7.109 | AT0(?) | 59 | ATTACHE | 1.3 | 66.2 | 0.1 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
4 x ATTACHE | +6.905 | +7.109 | AT0(?) | 60 | ATTACHE | 1.3 | 66.2 | 0.1 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
2 x ATTACHE | +5.398 | +5.603 | AT0(?) | 60 | ATTACHE | 1.3 | 66.2 | 0.1 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
12 x ATTACHE | +5.398 | +5.603 | AT0(?) | 3 | ATTACHE | 1.3 | 66.2 | 0.1 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
2 x ATTACHE | +5.398 | +5.603 | AT0(?) | 59 | ATTACHE | 1.3 | 66.2 | 0.1 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254

# IfcBeam: PL4*250 (22)
In: Undefined
Description: PL4*250; Material: STEEL/S235JR
Pset_BeamCommon - LoadBearing: yes; Reference: CO0(?)
Tekla Commun - Niveau bas: +0.000; Niveau haut: +0.054; Repère de pièce: CO0(?); Repère d'assemblage: CO0(?); Classe: 99; Matériau: S235JR; Profil: PL4*250; Nom: CORNIERE
Tekla Quantités - Poids: 0.9 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 67.1 m2; Surface nette: 0.1 m2; Hauteur: 250 mm; Largeur: 4 mm; Longueur: 100 mm
BaseQuantities - Length: 100 mm; OuterSurfaceArea: 0.054832 m2; NetVolume: 0.000104 m3; NetWeight: 0.8164 kg
Name | Phase
20 x CORNIERE | 65
2 x CORNIERE | 257

# IfcBeam: PL4*300 (34)
In: Undefined
Description: PL4*300; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: AT0(?); Repère d'assemblage: AT0(?); Classe: 99; Matériau: S235JR; Profil: PL4*300; Nom: ATTACHE
Tekla Quantités - Poids: 2 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 65.8 m2; Surface nette: 0.1 m2; Hauteur: 300 mm; Largeur: 4 mm; Longueur: 205 mm
Pset_BeamCommon - LoadBearing: yes; Reference: AT0(?)
BaseQuantities - Length: 205.003 mm; OuterSurfaceArea: 0.129474 m2; NetVolume: 0.000250804 m3; NetWeight: 1.96881 kg
Name | Niveau bas | Niveau haut | Phase
2 x ATTACHE | +2.889 | +2.936 | 252
2 x ATTACHE | +0.132 | +0.179 | 252
2 x ATTACHE | +2.632 | +2.679 | 252
4 x ATTACHE | +0.132 | +0.179 | 249
4 x ATTACHE | +2.632 | +2.679 | 249
4 x ATTACHE | +3.253 | +3.300 | 249
4 x ATTACHE | +2.953 | +3.000 | 249
4 x ATTACHE | +4.809 | +4.856 | 249
2 x ATTACHE | +0.132 | +0.179 | 248
2 x ATTACHE | +2.632 | +2.679 | 248
4 x ATTACHE | +4.809 | +4.856 | 248

# IfcBeam: PL4*360 (4)
In: Undefined
Description: PL4*360; Material: STEEL/Steel_Undefined
Pset_BeamCommon - LoadBearing: yes; Reference: A0(?)
Tekla Commun - Niveau bas: +5.728; Niveau haut: +5.991; Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 246; Classe: 6; Matériau: Steel_Undefined; Profil: PL4*360; Nom: AT CROIX
Tekla Quantités - Poids: 6.9 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64.8 m2; Surface nette: 0.4 m2; Hauteur: 360 mm; Largeur: 4 mm; Longueur: 602 mm
BaseQuantities - Length: 602 mm; OuterSurfaceArea: 0.44696 m2; NetVolume: 0.0008784 m3; NetWeight: 6.89544 kg

# IfcBeam: PL4*400 (8)
In: Undefined
Description: PL4*400; Material: STEEL/S235JR
Tekla Commun - Niveau bas: -0.025; Niveau haut: +0.029; Repère de pièce: CO0(?); Repère d'assemblage: CO0(?); Phase: 259; Classe: 99; Matériau: S235JR; Profil: PL4*400; Nom: CORNIERE
Tekla Quantités - Poids: 1.3 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 66.8 m2; Surface nette: 0.1 m2; Hauteur: 400 mm; Largeur: 4 mm; Longueur: 100 mm
Pset_BeamCommon - LoadBearing: yes; Reference: CO0(?)
BaseQuantities - Length: 100 mm; OuterSurfaceArea: 0.087232 m2; NetVolume: 0.0001664 m3; NetWeight: 1.30624 kg

# IfcBeam: SADEF-C+200X1.50 (164)
In: Undefined
Description: SADEF-C+200X1.50
Tekla Commun - Profil: SADEF-C+200X1.50
Tekla Quantités - Volume: 0 m3; Surface par tonne: 151.5 m2; Hauteur: 200 mm; Largeur: 100 mm
Pset_BeamCommon - LoadBearing: yes
Name | Material | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Phase | Classe | Matériau | Nom | Poids (kg) | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x LISSE | STEEL/S235JR | +1.054 | +1.154 | LS0(?) | 252 | 14 | S235JR | LISSE | 16.2 | 0.6 | 2.9 | 2860.1 | 2860.12 | 2.4597 | 0.00216225 | 16.9737
2 x LISSE | STEEL/S235JR | +1.159 | +2.100 | LS0(?) | 252 | 14 | S235JR | LISSE | 5.3 | 0 | 0.9 | 941 | 941 | 0.80926 | 0.000711396 | 5.58446
2 x LISSE | STEEL/S235JR | +2.105 | +2.205 | LS0(?) | 252 | 14 | S235JR | LISSE | 5.1 | 0.1 | 0.9 | 890 | 889.96 | 0.765365 | 0.00067281 | 5.28156
2 x LISSE | STEEL/S235JR | +2.105 | +2.205 | LS0(?) | 252 | 14 | S235JR | LISSE | 16.2 | 0.2 | 2.9 | 2860.1 | 2860.12 | 2.4597 | 0.00216225 | 16.9737
4 x LISSE | STEEL/S235JR | +0.179 | +0.279 | LS0(?) | 252 | 14 | S235JR | LISSE | 16.2 | 0.2 | 2.9 | 2860.5 | 2860.5 | 2.46003 | 0.00216254 | 16.9759
2 x LISSE | STEEL/S235JR | +2.679 | +2.779 | LS0(?) | 252 | 14 | S235JR | LISSE | 38.8 | 0.6 | 6.8 | 6833.2 | 6833.19 | 5.87655 | 0.00516589 | 40.5523
2 x LISSE | STEEL/S235JR | +2.789 | +2.889 | LS0(?) | 252 | 14 | S235JR | LISSE | 38.8 | 1.4 | 6.8 | 6833.2 | 6833.19 | 5.87655 | 0.00516589 | 40.5523
LISSE | STEEL/S235JR | +0.179 | +0.279 | LS0(?) | 257 | 14 | S235JR | LISSE | 33.5 | 0.5 | 6 | 5908.1 | 5908.07 | 5.08094 | 0.0044665 | 35.062
LISSE | STEEL/S235JR | +2.681 | +2.781 | LS0(?) | 257 | 14 | S235JR | LISSE | 33.5 | 0.5 | 6 | 5908.1 | 5908.07 | 5.08094 | 0.0044665 | 35.062
LISSE | STEEL/S235JR | +4.756 | +4.856 | LS0(?) | 257 | 14 | S235JR | LISSE | 33.5 | 0.5 | 6 | 5908.1 | 5908.07 | 5.08094 | 0.0044665 | 35.062
2 x LISSE | STEEL/S235JR | +0.179 | +0.279 | LS0(?) | 258 | 14 | S235JR | LISSE | 36.5 | 0.6 | 6.5 | 6431.3 | 6431.29 | 5.53091 | 0.00486205 | 38.1671
2 x LISSE | STEEL/S235JR | +2.681 | +2.781 | LS0(?) | 258 | 14 | S235JR | LISSE | 36.5 | 0.6 | 6.5 | 6431.3 | 6431.29 | 5.53091 | 0.00486205 | 38.1671
2 x LISSE | STEEL/S235JR | +4.756 | +4.856 | LS0(?) | 258 | 14 | S235JR | LISSE | 36.5 | 0.6 | 6.5 | 6431.3 | 6431.29 | 5.53091 | 0.00486205 | 38.1671
4 x LISSE | STEEL/S235JR | +0.179 | +0.279 | LS0(?) | 249 | 14 | S235JR | LISSE | 4 | 0.1 | 0.7 | 696.7 | 696.72 | 0.599179 | 0.00052672 | 4.13475
4 x LISSE | STEEL/S235JR | +2.679 | +2.779 | LS0(?) | 249 | 14 | S235JR | LISSE | 4 | 0.1 | 0.7 | 696.7 | 696.72 | 0.599179 | 0.00052672 | 4.13475
2 x LISSE | STEEL/S235JR | +3.300 | +3.400 | LS0(?) | 249 | 14 | S235JR | LISSE | 29 | 0.5 | 5.2 | 5103.5 | 5103.5 | 4.38901 | 0.00385825 | 30.2872
2 x LISSE | STEEL/S235JR | +3.000 | +3.100 | LS0(?) | 249 | 14 | S235JR | LISSE | 29 | 0.5 | 5.2 | 5103.5 | 5103.5 | 4.38901 | 0.00385825 | 30.2872
2 x LISSE | STEEL/S235JR | +4.856 | +4.956 | LS0(?) | 249 | 14 | S235JR | LISSE | 29 | 0.5 | 5.2 | 5103.5 | 5103.5 | 4.38901 | 0.00385825 | 30.2872
2 x LISSE | STEEL/S235JR | +2.679 | +2.779 | LS0(?) | 248 | 14 | S235JR | LISSE | 38.8 | 0.6 | 6.8 | 6833.2 | 6833.19 | 5.87655 | 0.00516589 | 40.5523
2 x LISSE | STEEL/S235JR | +0.179 | +0.279 | LS0(?) | 248 | 14 | S235JR | LISSE | 38.8 | 0.6 | 6.8 | 6833.2 | 6833.19 | 5.87655 | 0.00516589 | 40.5523
4 x LISSE | STEEL/S235JR | +4.856 | +4.956 | LS0(?) | 248 | 14 | S235JR | LISSE | 38.8 | 0.6 | 6.8 | 6833.2 | 6833.19 | 5.87655 | 0.00516589 | 40.5523
2 x ARBA | STEEL/Steel_Undefined | +6.339 | +6.712 | A0(?) | 246 | 6 | Steel_Undefined | ARBA | 14.2 | 0 | 2.5 | 2496.3 | 2496.27 | 2.14679 | 0.00188718 | 14.8144
2 x ARBA | STEEL/Steel_Undefined | +6.515 | +6.887 | A0(?) | 246 | 6 | Steel_Undefined | ARBA | 14.2 | 0 | 2.5 | 2491.7 | 2491.74 | 2.1429 | 0.00188375 | 14.7875
2 x ARBA | STEEL/Steel_Undefined | +6.339 | +6.887 | A0(?) | 246 | 6 | Steel_Undefined | ARBA | 29.6 | 0 | 5.3 | 5218 | 5218.01 | 4.48749 | 0.00394481 | 30.9668
2 x ARBA | STEEL/Steel_Undefined | +5.217 | +5.687 | A0(?) | 246 | 6 | Steel_Undefined | ARBA | 16.2 | 0 | 2.9 | 2856.2 | 2856.16 | 2.4563 | 0.00215926 | 16.9502
2 x ARBA | STEEL/Steel_Undefined | +5.217 | +5.958 | A0(?) | 246 | 6 | Steel_Undefined | ARBA | 33.1 | 0 | 5.8 | 5839.1 | 5839.14 | 5.02166 | 0.00441439 | 34.6529
2 x ARBA | STEEL/Steel_Undefined | +5.490 | +5.958 | A0(?) | 246 | 6 | Steel_Undefined | ARBA | 16.2 | 0 | 2.9 | 2838.9 | 2838.9 | 2.44146 | 0.00214621 | 16.8477
2 x ARBA | STEEL/Steel_Undefined | +5.761 | +6.228 | A0(?) | 246 | 6 | Steel_Undefined | ARBA | 16 | 0 | 2.9 | 2826.2 | 2826.16 | 2.4305 | 0.00213658 | 16.7722
2 x ARBA | STEEL/Steel_Undefined | +5.761 | +6.502 | A0(?) | 246 | 6 | Steel_Undefined | ARBA | 33.1 | 0 | 5.8 | 5839.1 | 5839.14 | 5.02166 | 0.00441439 | 34.6529
2 x ARBA | STEEL/Steel_Undefined | +6.031 | +6.502 | A0(?) | 246 | 6 | Steel_Undefined | ARBA | 16.3 | 0 | 2.9 | 2868.9 | 2868.9 | 2.46726 | 0.00216889 | 17.0258
2 x LISSE | STEEL/S235JR | +5.256 | +5.356 | LS0(?) | 65 | 14 | S235JR | LISSE | 28.3 | 0.5 | 5 | 4982 | 4982 | 4.28452 | 0.00376639 | 29.5662
2 x LISSE | STEEL/S235JR | +2.679 | +2.779 | LS0(?) | 65 | 14 | S235JR | LISSE | 28.3 | 0.5 | 5 | 4982 | 4982 | 4.28452 | 0.00376639 | 29.5662
2 x LISSE | STEEL/S235JR | +0.179 | +0.279 | LS0(?) | 65 | 14 | S235JR | LISSE | 28.3 | 0.5 | 5 | 4982 | 4982 | 4.28452 | 0.00376639 | 29.5662
LISSE | STEEL/S235JR | +5.256 | +5.356 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.7 | 0.5 | 5 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
LISSE | STEEL/S235JR | +2.679 | +2.779 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.7 | 0.5 | 5 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
LISSE | STEEL/S235JR | +0.179 | +0.279 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.7 | 0.5 | 5 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
4 x LISSE | STEEL/S235JR | +0.179 | +0.279 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.1 | 0.5 | 4.8 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
4 x LISSE | STEEL/S235JR | +2.679 | +2.779 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.1 | 0.5 | 4.8 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
4 x LISSE | STEEL/S235JR | +5.256 | +5.356 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.1 | 0.5 | 4.8 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
2 x PANNE | STEEL/S235JR | +6.889 | +7.102 | PA0(?) | 3 | 5 | S235JR | PANNE | 28.3 | 0 | 5 | 4982 | 4982 | 4.28452 | 0.00376639 | 29.5662
2 x PANNE | STEEL/S235JR | +6.889 | +7.102 | PA0(?) | 3 | 5 | S235JR | PANNE | 27.7 | 0 | 4.8 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
4 x PANNE | STEEL/S235JR | +6.889 | +7.102 | PA0(?) | 3 | 5 | S235JR | PANNE | 27.1 | 0 | 4.8 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
4 x RENFORT-ATTACHE | STEEL/S235JR | +1.179 | +1.379 | RA0(?) | 50 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.1 | 0.7 | 600 | 600 | 0.516 | 0.0004536 | 3.56076
4 x RENFORT-ATTACHE | STEEL/S235JR | +3.579 | +3.779 | RA0(?) | 50 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.1 | 0.7 | 600 | 600 | 0.516 | 0.0004536 | 3.56076
8 x RENFORT-ATTACHE | STEEL/S235JR | +2.579 | +2.679 | RA0(?) | 48 | 99 | S235JR | RENFORT-ATTACHE | 4.5 | 0.2 | 0.7 | 800 | 800 | 0.688 | 0.0006048 | 4.74768
8 x RENFORT-ATTACHE | STEEL/S235JR | +0.079 | +0.179 | RA0(?) | 48 | 99 | S235JR | RENFORT-ATTACHE | 4.5 | 0.2 | 0.7 | 800 | 800 | 0.688 | 0.0006048 | 4.74768
3 x RENFORT-ATTACHE | STEEL/S235JR | +4.679 | +4.879 | RA0(?) | 48 | 99 | S235JR | RENFORT-ATTACHE | 4.5 | 0.1 | 0.7 | 800 | 800 | 0.688 | 0.0006048 | 4.74768
4 x RENFORT-ATTACHE | STEEL/S235JR | +1.179 | +1.379 | RA0(?) | 48 | 99 | S235JR | RENFORT-ATTACHE | 4.5 | 0.1 | 0.7 | 800 | 800 | 0.688 | 0.0006048 | 4.74768
4 x RENFORT-ATTACHE | STEEL/S235JR | +3.579 | +3.779 | RA0(?) | 48 | 99 | S235JR | RENFORT-ATTACHE | 4.5 | 0.1 | 0.7 | 800 | 800 | 0.688 | 0.0006048 | 4.74768
2 x PANNE | STEEL/S235JR | +6.504 | +6.717 | PA0(?) | 3 | 5 | S235JR | PANNE | 28.3 | 0 | 5 | 4982 | 4982 | 4.28452 | 0.00376639 | 29.5662
2 x PANNE | STEEL/S235JR | +6.126 | +6.339 | PA0(?) | 3 | 5 | S235JR | PANNE | 28.3 | 0 | 5 | 4982 | 4982 | 4.28452 | 0.00376639 | 29.5662
2 x PANNE | STEEL/S235JR | +5.760 | +5.973 | PA0(?) | 3 | 5 | S235JR | PANNE | 28.3 | 0 | 5 | 4982 | 4982 | 4.28452 | 0.00376639 | 29.5662
2 x PANNE | STEEL/S235JR | +5.383 | +5.596 | PA0(?) | 3 | 5 | S235JR | PANNE | 28.3 | 0 | 5 | 4982 | 4982 | 4.28452 | 0.00376639 | 29.5662
2 x PANNE | STEEL/S235JR | +6.504 | +6.717 | PA0(?) | 3 | 5 | S235JR | PANNE | 27.7 | 0 | 4.8 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
2 x PANNE | STEEL/S235JR | +6.126 | +6.339 | PA0(?) | 3 | 5 | S235JR | PANNE | 27.7 | 0 | 4.8 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
2 x PANNE | STEEL/S235JR | +5.760 | +5.973 | PA0(?) | 3 | 5 | S235JR | PANNE | 27.7 | 0 | 4.8 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
2 x PANNE | STEEL/S235JR | +5.383 | +5.596 | PA0(?) | 3 | 5 | S235JR | PANNE | 27.7 | 0 | 4.8 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
4 x PANNE | STEEL/S235JR | +6.126 | +6.339 | PA0(?) | 3 | 5 | S235JR | PANNE | 27.1 | 0 | 4.8 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
4 x PANNE | STEEL/S235JR | +5.760 | +5.973 | PA0(?) | 3 | 5 | S235JR | PANNE | 27.1 | 0 | 4.8 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
4 x PANNE | STEEL/S235JR | +6.504 | +6.717 | PA0(?) | 3 | 5 | S235JR | PANNE | 27.1 | 0 | 4.8 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
4 x PANNE | STEEL/S235JR | +5.383 | +5.596 | PA0(?) | 3 | 5 | S235JR | PANNE | 27.1 | 0 | 4.8 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
LISSE | STEEL/S235JR | +5.256 | +5.356 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.7 | 0.5 | 4.8 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
LISSE | STEEL/S235JR | +2.679 | +2.779 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.7 | 0.5 | 4.8 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
LISSE | STEEL/S235JR | +0.179 | +0.279 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.7 | 0.5 | 4.8 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727

# IfcBeam: SADEF-C+200X2.00 (52)
In: Undefined
Description: SADEF-C+200X2.00; Material: STEEL/Steel_Undefined
Tekla Commun - Matériau: Steel_Undefined; Profil: SADEF-C+200X2.00
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 113.4 m2; Hauteur: 200 mm; Largeur: 100 mm
Pset_BeamCommon - LoadBearing: yes
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Phase | Classe | Nom | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
5 x POTEAU | -0.600 | +5.200 | P0(?) | 48 | 3 | POTEAU | 44 | 5.8 | 5800.3 | 5800.26 | 4.98822 | 0.00582346 | 45.7142
5 x POTEAU | -0.600 | +5.367 | P0(?) | 48 | 3 | POTEAU | 45.2 | 6 | 5967 | 5967 | 5.13162 | 0.00599087 | 47.0283
4 x ARBA | +5.377 | +7.110 | AB0(?) | 60 | 7 | ARBA | 76.4 | 10.2 | 10080.8 | 10080.8 | 8.66953 | 0.0101212 | 79.4512
4 x ARBA | +5.205 | +6.907 | AB0(?) | 60 | 7 | ARBA | 74.9 | 10 | 9874.9 | 9874.93 | 8.49244 | 0.00991443 | 77.8283
2 x ARBA | +4.862 | +6.502 | AB0(?) | 58 | 7 | ARBA | 71.8 | 9.5 | 9470.8 | 9470.85 | 8.14493 | 0.00950873 | 74.6436
2 x ARBA | +4.862 | +6.502 | AB0(?) | 56 | 7 | ARBA | 71.8 | 9.5 | 9470.8 | 9470.85 | 8.14493 | 0.00950873 | 74.6436
2 x ARBA | +5.034 | +6.705 | AB0(?) | 58 | 7 | ARBA | 73.4 | 9.8 | 9674.7 | 9674.7 | 8.32024 | 0.0097134 | 76.2502
2 x ARBA | +5.205 | +6.907 | AB0(?) | 58 | 7 | ARBA | 74.9 | 10 | 9874.9 | 9874.93 | 8.49244 | 0.00991443 | 77.8283
2 x ARBA | +5.377 | +7.110 | AB0(?) | 58 | 7 | ARBA | 76.4 | 10.2 | 10080.8 | 10080.8 | 8.66953 | 0.0101212 | 79.4512
2 x ARBA | +5.034 | +6.705 | AB0(?) | 56 | 7 | ARBA | 73.4 | 9.8 | 9674.7 | 9674.7 | 8.32024 | 0.0097134 | 76.2502
2 x ARBA | +5.205 | +6.907 | AB0(?) | 56 | 7 | ARBA | 74.9 | 10 | 9874.9 | 9874.93 | 8.49244 | 0.00991443 | 77.8283
2 x ARBA | +5.377 | +7.110 | AB0(?) | 56 | 7 | ARBA | 76.4 | 10.2 | 10080.8 | 10080.8 | 8.66953 | 0.0101212 | 79.4512
2 x ARBA | +5.205 | +6.907 | AB0(?) | 57 | 7 | ARBA | 74.9 | 10 | 9874.9 | 9874.93 | 8.49244 | 0.00991443 | 77.8283
2 x ARBA | +5.377 | +7.110 | AB0(?) | 57 | 7 | ARBA | 76.4 | 10.2 | 10080.8 | 10080.8 | 8.66953 | 0.0101212 | 79.4512
2 x POTEAU | +0.005 | +2.674 | P0(?) | 252 | 3 | POTEAU | 20.2 | 2.7 | 2669 | 2669 | 2.29534 | 0.00267968 | 21.0355
2 x POTEAU | +0.005 | +6.218 | P0(?) | 258 | 3 | POTEAU | 47.1 | 6.3 | 6213.5 | 6213.49 | 5.3436 | 0.00623834 | 48.971
2 x POTEAU | +0.005 | +2.995 | P0(?) | 249 | 3 | POTEAU | 22.7 | 2.9 | 2990 | 2990 | 2.5714 | 0.00300196 | 23.5654
2 x POTEAU | -0.400 | +6.286 | P0(?) | 48 | 3 | POTEAU | 50.7 | 6.7 | 6685.5 | 6685.51 | 5.74954 | 0.00671225 | 52.6912
2 x POTEAU | -0.400 | +6.479 | P0(?) | 48 | 3 | POTEAU | 52.2 | 6.8 | 6879 | 6878.99 | 5.91593 | 0.00690651 | 54.2161
2 x POTEAU | -0.600 | +4.857 | P0(?) | 48 | 3 | POTEAU | 41.4 | 5.5 | 5456.7 | 5456.65 | 4.69272 | 0.00547848 | 43.006
2 x POTEAU | -0.600 | +5.029 | P0(?) | 48 | 3 | POTEAU | 42.7 | 5.7 | 5628.7 | 5628.65 | 4.84064 | 0.00565116 | 44.3616

# IfcColumn: SADEF-C+200X1.50 (2)
In: Undefined
Description: SADEF-C+200X1.50; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +1.159; Niveau haut: +2.100; Repère de pièce: LS0(?); Repère d'assemblage: LS0(?); Phase: 252; Classe: 14; Matériau: S235JR; Profil: SADEF-C+200X1.50; Nom: LISSE
Tekla Quantités - Poids: 5.3 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 151.5 m2; Surface nette: 0.9 m2; Hauteur: 200 mm; Largeur: 100 mm; Longueur: 941 mm
BaseQuantities - Length: 941 mm; OuterSurfaceArea: 0.80926 m2; NetVolume: 0.000711396 m3; NetWeight: 5.58446 kg
Pset_ColumnCommon - LoadBearing: yes; Reference: LS0(?)

# IfcColumn: SADEF-C+200X2.00 (24)
In: Undefined
Description: SADEF-C+200X2.00; Material: STEEL/Steel_Undefined
Tekla Commun - Repère de pièce: P0(?); Repère d'assemblage: P0(?); Classe: 3; Matériau: Steel_Undefined; Profil: SADEF-C+200X2.00; Nom: POTEAU
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 113.4 m2; Hauteur: 200 mm; Largeur: 100 mm
Pset_ColumnCommon - LoadBearing: yes; Reference: P0(?)
Name | Niveau bas | Niveau haut | Phase | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
5 x POTEAU | -0.600 | +5.200 | 48 | 44 | 5.8 | 5800.3 | 5800.26 | 4.98822 | 0.00582346 | 45.7142
5 x POTEAU | -0.600 | +5.367 | 48 | 45.2 | 6 | 5967 | 5967 | 5.13162 | 0.00599087 | 47.0283
2 x POTEAU | -0.600 | +4.857 | 48 | 41.4 | 5.5 | 5456.7 | 5456.65 | 4.69272 | 0.00547848 | 43.006
2 x POTEAU | -0.600 | +5.029 | 48 | 42.7 | 5.7 | 5628.7 | 5628.65 | 4.84064 | 0.00565116 | 44.3616
2 x POTEAU | +0.005 | +2.674 | 252 | 20.2 | 2.7 | 2669 | 2669 | 2.29534 | 0.00267968 | 21.0355
2 x POTEAU | +0.005 | +6.218 | 258 | 47.1 | 6.3 | 6213.5 | 6213.49 | 5.3436 | 0.00623834 | 48.971
2 x POTEAU | +0.005 | +2.995 | 249 | 22.7 | 2.9 | 2990 | 2990 | 2.5714 | 0.00300196 | 23.5654
2 x POTEAU | -0.400 | +6.286 | 48 | 50.7 | 6.7 | 6685.5 | 6685.51 | 5.74954 | 0.00671225 | 52.6912
2 x POTEAU | -0.400 | +6.479 | 48 | 52.2 | 6.8 | 6879 | 6878.99 | 5.91593 | 0.00690651 | 54.2161

# IfcElementAssembly (747)
In: Undefined
Name | PredefinedType | Poids Assemblage/Elément béton (kg) | Niveau Bas Assemblage/Elément béton | Niveau Haut Assemblage/Elément béton | Position maillage Assemblage/Elément béton | Repère Assemblage/Elément béton | Width (mm)
2 x Steel Assembly | RIGID_FRAME | 1.3 | +2.518 | +2.889 | 2-3/A | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 18.7 | +0.255 | +2.695 | 2-3/A | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.9 | +4.953 | +5.103 | 2/A | A0(?) | 210
Steel Assembly | RIGID_FRAME | 18.7 | +2.712 | +5.146 | 2-3/A | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.9 | +4.953 | +5.103 | 3/A | A0(?) | 210
Steel Assembly | RIGID_FRAME | 2.9 | +0.304 | +0.454 | 3/A | A0(?) | 210
Steel Assembly | RIGID_FRAME | 2.9 | +0.304 | +0.454 | 2/A | A0(?) | 210
Steel Assembly | RIGID_FRAME | 38.1 | +0.255 | +5.146 | 2-3/A | A0(?) | 100
Steel Assembly | RIGID_FRAME | 44 | -0.600 | +5.200 | 1/A | P0(?) | 100
Steel Assembly | RIGID_FRAME | 45.2 | -0.600 | +5.367 | 1/A | P0(?) | 100
Steel Assembly | RIGID_FRAME | 41.4 | -0.600 | +4.857 | 2/A-B | P0(?) | 100
Steel Assembly | RIGID_FRAME | 42.7 | -0.600 | +5.029 | 2/A-B | P0(?) | 100
Steel Assembly | RIGID_FRAME | 44 | -0.600 | +5.200 | 2/A | P0(?) | 100
Steel Assembly | RIGID_FRAME | 45.2 | -0.600 | +5.367 | 2/A | P0(?) | 100
Steel Assembly | RIGID_FRAME | 41.4 | -0.600 | +4.857 | 4/A-B | P0(?) | 100
Steel Assembly | RIGID_FRAME | 44 | -0.600 | +5.200 | 3/A | P0(?) | 100
Steel Assembly | RIGID_FRAME | 45.2 | -0.600 | +5.367 | 3/A | P0(?) | 100
Steel Assembly | RIGID_FRAME | 44 | -0.600 | +5.200 | 5/A | P0(?) | 100
Steel Assembly | RIGID_FRAME | 45.2 | -0.600 | +5.367 | 5/A | P0(?) | 100
Steel Assembly | RIGID_FRAME | 42.7 | -0.600 | +5.029 | 4/A-B | P0(?) | 100
Steel Assembly | RIGID_FRAME | 44 | -0.600 | +5.200 | 4/A | P0(?) | 100
Steel Assembly | RIGID_FRAME | 45.2 | -0.600 | +5.367 | 4/A | P0(?) | 100
Steel Assembly | RIGID_FRAME | 14.5 | +6.272 | +7.115 | 4/F | G0(?) | 4
Steel Assembly | RIGID_FRAME | 76.4 | +5.377 | +7.110 | 1/A-F | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 74.9 | +5.205 | +6.907 | 1/A-F | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 71.8 | +4.862 | +6.502 | 4/A-F | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 71.8 | +4.862 | +6.502 | 2/A-F | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 74.9 | +5.205 | +6.907 | 5/A-F | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 76.4 | +5.377 | +7.110 | 5/A-F | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 73.4 | +5.034 | +6.705 | 4/A-F | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 74.9 | +5.205 | +6.907 | 4/A-F | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 76.4 | +5.377 | +7.110 | 4/A-F | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 73.4 | +5.034 | +6.705 | 2/A-F | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 74.9 | +5.205 | +6.907 | 2/A-F | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 76.4 | +5.377 | +7.110 | 2/A-F | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 74.9 | +5.205 | +6.907 | 3/A-F | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 76.4 | +5.377 | +7.110 | 3/A-F | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 76.4 | +5.377 | +7.110 | 1/F-L | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 14.5 | +6.272 | +7.115 | 2/F | G0(?) | 4
Steel Assembly | RIGID_FRAME | 8.3 | +6.665 | +7.115 | 5/F | G0(?) | 4
Steel Assembly | RIGID_FRAME | 8.3 | +6.665 | +7.115 | 3/F | G0(?) | 4
Steel Assembly | RIGID_FRAME | 8.3 | +6.665 | +7.115 | 1/F | G0(?) | 4
Steel Assembly | RIGID_FRAME | 74.9 | +5.205 | +6.907 | 1/F-L | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 71.8 | +4.862 | +6.502 | 4/F-L | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 71.8 | +4.862 | +6.502 | 2/F-L | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 74.9 | +5.205 | +6.907 | 5/F-L | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 76.4 | +5.377 | +7.110 | 5/F-L | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 73.4 | +5.034 | +6.705 | 4/F-L | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 74.9 | +5.205 | +6.907 | 4/F-L | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 76.4 | +5.377 | +7.110 | 4/F-L | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 73.4 | +5.034 | +6.705 | 2/F-L | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 74.9 | +5.205 | +6.907 | 2/F-L | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 76.4 | +5.377 | +7.110 | 2/F-L | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 74.9 | +5.205 | +6.907 | 3/F-L | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 76.4 | +5.377 | +7.110 | 3/F-L | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 6.9 | +5.054 | +5.636 | 3/A | G0(?) | 4
Steel Assembly | RIGID_FRAME | 6.9 | +5.054 | +5.636 | 3/L | G0(?) | 4
2 x Steel Assembly | RIGID_FRAME | 20.2 | +0.005 | +2.674 | 5/I-K | P0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 20.2 | +0.005 | +2.674 | 1/B-C | P0(?) | 100
Steel Assembly | RIGID_FRAME | 16.2 | +1.054 | +1.154 | 5/I-L | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 16.2 | +2.105 | +2.205 | 5/I-L | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +1.154 | +1.206 | 5/K-L | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 5.3 | +1.159 | +2.100 | 5/K-L | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +2.053 | +2.105 | 5/K-L | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 5.3 | +1.159 | +2.100 | 5/K | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +1.154 | +1.206 | 5/K | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 5.1 | +2.105 | +2.205 | 5/I-K | LS0(?) | 100
3 x Steel Assembly | RIGID_FRAME | 0.6 | +2.063 | +2.105 | 5/I-K | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +2.053 | +2.105 | 5/K | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +1.012 | +1.054 | 5/L | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +1.012 | +1.054 | 5/I-K | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +2.063 | +2.105 | 5/L | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 16.2 | +0.179 | +0.279 | 5/I-L | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 16.2 | +0.179 | +0.279 | 5/H-K | LS0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 0.6 | +0.137 | +0.179 | 5/I-K | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 38.8 | +2.679 | +2.779 | 5/H-L | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 38.8 | +2.789 | +2.889 | 5/H-L | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 2 | +2.889 | +2.936 | 5/H | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +2.889 | +2.936 | 5/K-L | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 0.6 | +2.637 | +2.679 | 5/I-K | PL0(?) | 52
2 x Steel Assembly | RIGID_FRAME | 0.9 | +0.000 | +0.102 | 5/I-K | PL0(?) | 52
2 x Steel Assembly | RIGID_FRAME | 2 | +0.132 | +0.179 | 5/H | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 2 | +2.632 | +2.679 | 5/H | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +0.132 | +0.179 | 5/K-L | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +2.632 | +2.679 | 5/K-L | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 44 | -0.600 | +5.200 | 1/L | P0(?) | 100
Steel Assembly | RIGID_FRAME | 45.2 | -0.600 | +5.367 | 1/L | P0(?) | 100
Steel Assembly | RIGID_FRAME | 41.4 | -0.600 | +4.857 | 2/K-L | P0(?) | 100
Steel Assembly | RIGID_FRAME | 42.7 | -0.600 | +5.029 | 2/K-L | P0(?) | 100
Steel Assembly | RIGID_FRAME | 44 | -0.600 | +5.200 | 2/L | P0(?) | 100
Steel Assembly | RIGID_FRAME | 45.2 | -0.600 | +5.367 | 2/L | P0(?) | 100
Steel Assembly | RIGID_FRAME | 41.4 | -0.600 | +4.857 | 4/K-L | P0(?) | 100
Steel Assembly | RIGID_FRAME | 44 | -0.600 | +5.200 | 3/L | P0(?) | 100
Steel Assembly | RIGID_FRAME | 45.2 | -0.600 | +5.367 | 3/L | P0(?) | 100
Steel Assembly | RIGID_FRAME | 44 | -0.600 | +5.200 | 5/L | P0(?) | 100
Steel Assembly | RIGID_FRAME | 45.2 | -0.600 | +5.367 | 5/L | P0(?) | 100
Steel Assembly | RIGID_FRAME | 42.7 | -0.600 | +5.029 | 4/K-L | P0(?) | 100
Steel Assembly | RIGID_FRAME | 44 | -0.600 | +5.200 | 4/L | P0(?) | 100
Steel Assembly | RIGID_FRAME | 45.2 | -0.600 | +5.367 | 4/L | P0(?) | 100
Steel Assembly | RIGID_FRAME | 16.2 | +1.054 | +1.154 | 1/A-C | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 16.2 | +2.105 | +2.205 | 1/A-C | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +1.154 | +1.206 | 1/A-B | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 5.3 | +1.159 | +2.100 | 1/A-B | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +2.053 | +2.105 | 1/A-B | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 5.3 | +1.159 | +2.100 | 1/B | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +1.154 | +1.206 | 1/B | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 5.1 | +2.105 | +2.205 | 1/B-C | LS0(?) | 100
3 x Steel Assembly | RIGID_FRAME | 0.6 | +2.063 | +2.105 | 1/B-C | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +2.053 | +2.105 | 1/B | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 33.5 | +0.179 | +0.279 | 3/D-H | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 33.5 | +2.681 | +2.781 | 3/D-H | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 33.5 | +4.756 | +4.856 | 3/D-H | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +1.012 | +1.054 | 1/A | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +1.012 | +1.054 | 1/B-C | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +2.063 | +2.105 | 1/A | PL0(?) | 52
2 x Steel Assembly | RIGID_FRAME | 0.9 | +0.000 | +0.102 | 3/C-D | PL0(?) | 72
Steel Assembly | RIGID_FRAME | 1.3 | +0.132 | +0.179 | 3/D | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +2.634 | +2.681 | 3/D | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +4.709 | +4.756 | 3/D | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 47.1 | +0.005 | +6.218 | 3/C-D | P0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 0.9 | +0.000 | +0.102 | 3/H-I | PL0(?) | 72
Steel Assembly | RIGID_FRAME | 1.3 | +0.132 | +0.179 | 3/H | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +2.634 | +2.681 | 3/H | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +4.709 | +4.756 | 3/H | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 47.1 | +0.005 | +6.218 | 3/H-I | P0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 0.9 | +1.209 | +1.349 | 3/L | PLA0(?) | 2
2 x Steel Assembly | RIGID_FRAME | 0.9 | +3.709 | +3.849 | 3/L | PLA0(?) | 2
2 x Steel Assembly | RIGID_FRAME | 0.9 | +1.209 | +1.349 | 3/A | PLA0(?) | 2
2 x Steel Assembly | RIGID_FRAME | 0.9 | +3.709 | +3.849 | 3/A | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 1.3 | +0.132 | +0.179 | 3/C-D | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +2.634 | +2.681 | 3/C-D | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +4.709 | +4.756 | 3/C-D | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +0.132 | +0.179 | 3/H-I | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +2.634 | +2.681 | 3/H-I | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 36.5 | +0.179 | +0.279 | 3/A-D | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 36.5 | +2.681 | +2.781 | 3/A-D | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 36.5 | +4.756 | +4.856 | 3/A-D | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 36.5 | +0.179 | +0.279 | 3/H-L | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 36.5 | +2.681 | +2.781 | 3/H-L | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 36.5 | +4.756 | +4.856 | 3/H-L | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +0.132 | +0.179 | 3/A-B | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +2.634 | +2.681 | 3/A-B | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +4.709 | +4.756 | 3/A-B | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 0.6 | +6.142 | +6.243 | 3/C-D | AT0(?) | 31.9546
Steel Assembly | RIGID_FRAME | 50.7 | -0.400 | +6.286 | 1/D | P0(?) | 100
Steel Assembly | RIGID_FRAME | 52.2 | -0.400 | +6.479 | 1/D | P0(?) | 100
Steel Assembly | RIGID_FRAME | 50.7 | -0.400 | +6.286 | 1/H | P0(?) | 100
Steel Assembly | RIGID_FRAME | 52.2 | -0.400 | +6.479 | 1/H | P0(?) | 100
Steel Assembly | RIGID_FRAME | 50.7 | -0.400 | +6.286 | 5/D | P0(?) | 100
Steel Assembly | RIGID_FRAME | 52.2 | -0.400 | +6.479 | 5/D | P0(?) | 100
Steel Assembly | RIGID_FRAME | 50.7 | -0.400 | +6.286 | 5/H | P0(?) | 100
Steel Assembly | RIGID_FRAME | 52.2 | -0.400 | +6.479 | 5/H | P0(?) | 100
Steel Assembly | RIGID_FRAME | 16.2 | +0.179 | +0.279 | 1/A-C | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 16.2 | +0.179 | +0.279 | 1/B-D | LS0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 0.6 | +0.137 | +0.179 | 1/B-C | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 38.8 | +2.679 | +2.779 | 1/A-D | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 38.8 | +2.789 | +2.889 | 1/A-D | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 2 | +2.889 | +2.936 | 1/D | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +2.889 | +2.936 | 1/A-B | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 0.6 | +2.637 | +2.679 | 1/B-C | PL0(?) | 52
2 x Steel Assembly | RIGID_FRAME | 0.9 | +0.000 | +0.102 | 1/B-C | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 22.7 | +0.005 | +2.995 | 5/E | P0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +0.137 | +0.179 | 5/E | PL0(?) | 52
2 x Steel Assembly | RIGID_FRAME | 2 | +0.132 | +0.179 | 5/D | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 4 | +0.179 | +0.279 | 5/D-E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +2.637 | +2.679 | 5/E | PL0(?) | 52
2 x Steel Assembly | RIGID_FRAME | 2 | +2.632 | +2.679 | 5/D | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 4 | +2.679 | +2.779 | 5/D-E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +0.137 | +0.179 | 5/G | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 4 | +0.179 | +0.279 | 5/G-H | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +2.637 | +2.679 | 5/G | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 4 | +2.679 | +2.779 | 5/G-H | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 22.7 | +0.005 | +2.995 | 5/G | P0(?) | 100
Steel Assembly | RIGID_FRAME | 22.7 | +0.005 | +2.995 | 1/E | P0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +0.137 | +0.179 | 1/E | PL0(?) | 52
2 x Steel Assembly | RIGID_FRAME | 2 | +0.132 | +0.179 | 1/D | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 4 | +0.179 | +0.279 | 1/D-E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +2.637 | +2.679 | 1/E | PL0(?) | 52
2 x Steel Assembly | RIGID_FRAME | 2 | +2.632 | +2.679 | 1/D | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 4 | +2.679 | +2.779 | 1/D-E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +0.137 | +0.179 | 1/G | PL0(?) | 52
2 x Steel Assembly | RIGID_FRAME | 2 | +0.132 | +0.179 | 1/H | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 4 | +0.179 | +0.279 | 1/G-H | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 22.7 | +0.005 | +2.995 | 1/G | P0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +2.637 | +2.679 | 1/G | PL0(?) | 52
2 x Steel Assembly | RIGID_FRAME | 2 | +2.632 | +2.679 | 1/H | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 4 | +2.679 | +2.779 | 1/G-H | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 38.8 | +2.679 | +2.779 | 1/H-L | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +4.709 | +4.756 | 3/H-I | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +0.132 | +0.179 | 3/K-L | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +2.634 | +2.681 | 3/K-L | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +4.709 | +4.756 | 3/K-L | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 2 | +3.253 | +3.300 | 5/D | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 2 | +3.253 | +3.300 | 5/H | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 29 | +3.300 | +3.400 | 5/D-H | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 2 | +2.953 | +3.000 | 5/D | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 2 | +2.953 | +3.000 | 5/H | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 29 | +3.000 | +3.100 | 5/D-H | LS0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 2 | +4.809 | +4.856 | 5/D | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 2 | +4.809 | +4.856 | 5/H | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 29 | +4.856 | +4.956 | 5/D-H | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +2.958 | +3.000 | 5/E | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.9 | +0.000 | +0.102 | 5/E | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +2.958 | +3.000 | 5/G | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.9 | +0.000 | +0.102 | 5/G | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 29 | +3.000 | +3.100 | 1/D-H | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 2 | +3.253 | +3.300 | 1/D | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 2 | +3.253 | +3.300 | 1/H | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 29 | +3.300 | +3.400 | 1/D-H | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 2 | +2.953 | +3.000 | 1/D | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 2 | +2.953 | +3.000 | 1/H | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 38.8 | +2.679 | +2.779 | 5/A-D | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +0.132 | +0.179 | 5/A-B | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +2.632 | +2.679 | 5/A-B | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 38.8 | +0.179 | +0.279 | 5/A-D | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 38.8 | +4.856 | +4.956 | 5/A-D | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +4.809 | +4.856 | 5/A-B | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 38.8 | +4.856 | +4.956 | 5/H-L | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +4.809 | +4.856 | 5/K-L | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 2 | +4.809 | +4.856 | 1/D | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 2 | +4.809 | +4.856 | 1/H | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +0.132 | +0.179 | 1/A-B | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +2.632 | +2.679 | 1/A-B | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 38.8 | +4.856 | +4.956 | 1/A-D | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +4.809 | +4.856 | 1/A-B | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +0.132 | +0.179 | 1/K-L | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +2.632 | +2.679 | 1/K-L | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 38.8 | +0.179 | +0.279 | 1/H-L | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 38.8 | +4.856 | +4.956 | 1/H-L | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 29 | +4.856 | +4.956 | 1/D-H | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +4.809 | +4.856 | 1/K-L | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 0.6 | +2.958 | +3.000 | 1/E | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.9 | +0.000 | +0.102 | 1/E | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +2.958 | +3.000 | 1/G | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.9 | +0.000 | +0.102 | 1/G | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.9 | +2.679 | +2.779 | 5/D | An0(?) | 251
Steel Assembly | RIGID_FRAME | 0.9 | +0.179 | +0.279 | 5/D | An0(?) | 251
Steel Assembly | RIGID_FRAME | 0.9 | +2.679 | +2.779 | 5/H | An0(?) | 251
Steel Assembly | RIGID_FRAME | 0.9 | +0.179 | +0.279 | 5/H | An0(?) | 251
Steel Assembly | RIGID_FRAME | 0.6 | +6.142 | +6.243 | 3/H-I | AT0(?) | 31.9546
Steel Assembly | RIGID_FRAME | 0.5 | +4.856 | +4.956 | 5/D | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.5 | +4.856 | +4.956 | 5/H | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +4.856 | +4.956 | 5/A | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +0.179 | +0.279 | 5/A | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +2.679 | +2.779 | 5/A | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +4.856 | +4.956 | 5/L | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +0.179 | +0.279 | 5/L | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +2.679 | +2.779 | 5/L | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.5 | +4.856 | +4.956 | 1/D | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.5 | +4.856 | +4.956 | 1/H | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.9 | +2.679 | +2.779 | 1/D | An0(?) | 251
Steel Assembly | RIGID_FRAME | 0.9 | +0.179 | +0.279 | 1/D | An0(?) | 251
Steel Assembly | RIGID_FRAME | 0.9 | +2.679 | +2.779 | 1/H | An0(?) | 251
Steel Assembly | RIGID_FRAME | 0.9 | +0.179 | +0.279 | 1/H | An0(?) | 251
Steel Assembly | RIGID_FRAME | 0.6 | +4.856 | +4.956 | 1/A | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +0.179 | +0.279 | 1/A | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +2.679 | +2.779 | 1/A | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +4.856 | +4.956 | 1/L | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +0.179 | +0.279 | 1/L | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +2.679 | +2.779 | 1/L | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 1.5 | +6.690 | +6.738 | 2-3/E-F | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 14.1 | +6.515 | +6.887 | 2-3/E-F | A0(?) | 100
Steel Assembly | RIGID_FRAME | 14.1 | +6.339 | +6.712 | 2-3/D-E | A0(?) | 100
Steel Assembly | RIGID_FRAME | 29.6 | +6.339 | +6.887 | 2-3/D-F | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.9 | +6.332 | +6.563 | 2/D | A0(?) | 210
2 x Steel Assembly | RIGID_FRAME | 2.9 | +6.662 | +6.893 | 3/F | A0(?) | 210
Steel Assembly | RIGID_FRAME | 2.9 | +6.332 | +6.563 | 3/D | A0(?) | 210
2 x Steel Assembly | RIGID_FRAME | 2.9 | +6.662 | +6.893 | 2/F | A0(?) | 210
Steel Assembly | RIGID_FRAME | 6.9 | +5.728 | +5.991 | 3/B-C | A0(?) | 210
Steel Assembly | RIGID_FRAME | 6.9 | +5.728 | +5.991 | 2/B-C | A0(?) | 210
Steel Assembly | RIGID_FRAME | 1.5 | +6.488 | +6.536 | 2-3/E-F | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 2.9 | +5.211 | +5.442 | 3/A | A0(?) | 210
Steel Assembly | RIGID_FRAME | 1.5 | +5.458 | +5.517 | 2-3/A-B | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 1.5 | +5.660 | +5.719 | 2-3/A-B | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 16.2 | +5.217 | +5.687 | 2-3/A-B | A0(?) | 100
Steel Assembly | RIGID_FRAME | 33.1 | +5.217 | +5.958 | 2-3/A-C | A0(?) | 100
Steel Assembly | RIGID_FRAME | 16.2 | +5.490 | +5.958 | 2-3/B-C | A0(?) | 100
Steel Assembly | RIGID_FRAME | 1.5 | +5.999 | +6.058 | 2-3/C-D | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 1.5 | +6.201 | +6.260 | 2-3/C-D | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 16 | +5.761 | +6.228 | 2-3/B-D | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.9 | +6.277 | +6.508 | 3/D | A0(?) | 210
Steel Assembly | RIGID_FRAME | 33.1 | +5.761 | +6.502 | 2-3/B-D | A0(?) | 100
Steel Assembly | RIGID_FRAME | 16.3 | +6.031 | +6.502 | 2-3/C-D | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.9 | +5.211 | +5.442 | 2/A | A0(?) | 210
Steel Assembly | RIGID_FRAME | 2.9 | +6.277 | +6.508 | 2/D | A0(?) | 210
Steel Assembly | RIGID_FRAME | 1.5 | +6.690 | +6.738 | 2-3/F-G | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 14.1 | +6.515 | +6.887 | 2-3/F-G | A0(?) | 100
Steel Assembly | RIGID_FRAME | 14.1 | +6.339 | +6.712 | 2-3/G-H | A0(?) | 100
Steel Assembly | RIGID_FRAME | 29.6 | +6.339 | +6.887 | 2-3/F-H | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.9 | +6.332 | +6.563 | 2/H | A0(?) | 210
Steel Assembly | RIGID_FRAME | 2.9 | +6.332 | +6.563 | 3/H | A0(?) | 210
Steel Assembly | RIGID_FRAME | 6.9 | +5.728 | +5.991 | 3/I-K | A0(?) | 210
Steel Assembly | RIGID_FRAME | 6.9 | +5.728 | +5.991 | 2/I-K | A0(?) | 210
Steel Assembly | RIGID_FRAME | 1.5 | +6.488 | +6.536 | 2-3/F-G | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 2.9 | +5.211 | +5.442 | 3/L | A0(?) | 210
Steel Assembly | RIGID_FRAME | 1.5 | +5.458 | +5.517 | 2-3/K-L | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 1.5 | +5.660 | +5.719 | 2-3/K-L | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 16.2 | +5.217 | +5.687 | 2-3/K-L | A0(?) | 100
Steel Assembly | RIGID_FRAME | 33.1 | +5.217 | +5.958 | 2-3/I-L | A0(?) | 100
Steel Assembly | RIGID_FRAME | 16.2 | +5.490 | +5.958 | 2-3/I-K | A0(?) | 100
Steel Assembly | RIGID_FRAME | 1.5 | +5.999 | +6.058 | 2-3/H-I | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 1.5 | +6.201 | +6.260 | 2-3/H-I | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 16 | +5.761 | +6.228 | 2-3/H-K | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.9 | +6.277 | +6.508 | 3/H | A0(?) | 210
Steel Assembly | RIGID_FRAME | 33.1 | +5.761 | +6.502 | 2-3/H-K | A0(?) | 100
Steel Assembly | RIGID_FRAME | 16.3 | +6.031 | +6.502 | 2-3/H-I | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.9 | +5.211 | +5.442 | 2/L | A0(?) | 210
Steel Assembly | RIGID_FRAME | 2.9 | +6.277 | +6.508 | 2/H | A0(?) | 210
2 x Steel Assembly | RIGID_FRAME | 1.3 | +2.518 | +2.889 | 2-3/L | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 18.7 | +0.255 | +2.695 | 2-3/L | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.9 | +4.953 | +5.103 | 2/L | A0(?) | 210
Steel Assembly | RIGID_FRAME | 18.7 | +2.712 | +5.146 | 2-3/L | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.9 | +4.953 | +5.103 | 3/L | A0(?) | 210
Steel Assembly | RIGID_FRAME | 2.9 | +0.304 | +0.454 | 3/L | A0(?) | 210
Steel Assembly | RIGID_FRAME | 2.9 | +0.304 | +0.454 | 2/L | A0(?) | 210
Steel Assembly | RIGID_FRAME | 38.1 | +0.255 | +5.146 | 2-3/L | A0(?) | 100
Steel Assembly |  | 181.7 | -0.650 | -0.000 | 5/K-L | S0(?) | 130
2 x Steel Assembly |  | 3036 | -1.000 | -0.000 | 4-5/K-L | S0(?) | 1000
Steel Assembly |  | 181.7 | -0.650 | -0.000 | 5/A-B | S0(?) | 130
2 x Steel Assembly |  | 3036 | -1.000 | -0.000 | 4-5/A-B | S0(?) | 1000
Steel Assembly |  | 181.7 | -0.650 | -0.000 | 4/K-L | S0(?) | 130
Steel Assembly |  | 181.7 | -0.650 | -0.000 | 4/A-B | S0(?) | 130
Steel Assembly |  | 181.7 | -0.650 | -0.000 | 3/K-L | S0(?) | 130
2 x Steel Assembly |  | 3036 | -1.000 | -0.000 | 2-3/K-L | S0(?) | 1000
Steel Assembly |  | 181.7 | -0.650 | -0.000 | 3/A-B | S0(?) | 130
2 x Steel Assembly |  | 3036 | -1.000 | -0.000 | 2-3/A-B | S0(?) | 1000
Steel Assembly |  | 181.7 | -0.650 | -0.000 | 2/K-L | S0(?) | 130
Steel Assembly |  | 181.7 | -0.650 | -0.000 | 2/A-B | S0(?) | 130
2 x Steel Assembly | RIGID_FRAME | 1.3 | -0.025 | +0.029 | 5/H | CO0(?) | 54
2 x Steel Assembly | RIGID_FRAME | 1.3 | -0.025 | +0.029 | 5/D | CO0(?) | 54
Steel Assembly |  | 86.1 | -0.475 | -0.025 | 5/H | S0(?) | 275
Steel Assembly |  | 1295.4 | -0.825 | -0.025 | 4-5/H-I | S0(?) | 800
Steel Assembly |  | 86.1 | -0.475 | -0.025 | 5/D | S0(?) | 275
Steel Assembly |  | 1295.4 | -0.825 | -0.025 | 4-5/C-D | S0(?) | 800
2 x Steel Assembly | RIGID_FRAME | 1.3 | -0.025 | +0.029 | 1/H | CO0(?) | 54
Steel Assembly |  | 86.1 | -0.475 | -0.025 | 1/H | S0(?) | 275
Steel Assembly |  | 1295.4 | -0.825 | -0.025 | 1-2/H-I | S0(?) | 800
Steel Assembly |  | 181.7 | -0.650 | -0.000 | 1/K-L | S0(?) | 130
Steel Assembly |  | 3036 | -1.000 | -0.000 | 1-2/K-L | S0(?) | 1000
2 x Steel Assembly | RIGID_FRAME | 1.3 | -0.025 | +0.029 | 1/D | CO0(?) | 54
Steel Assembly |  | 86.1 | -0.475 | -0.025 | 1/D | S0(?) | 275
Steel Assembly |  | 1295.4 | -0.825 | -0.025 | 1-2/C-D | S0(?) | 800
Steel Assembly |  | 181.7 | -0.650 | -0.000 | 1/A-B | S0(?) | 130
Steel Assembly |  | 3036 | -1.000 | -0.000 | 1-2/A-B | S0(?) | 1000
2 x Steel Assembly | RIGID_FRAME | 0.9 | +6.559 | +6.670 | 4/D | AT0(?) | 270.003
2 x Steel Assembly | RIGID_FRAME | 0.9 | +6.559 | +6.670 | 3/D | AT0(?) | 270.003
2 x Steel Assembly | RIGID_FRAME | 0.9 | +6.559 | +6.670 | 2/D | AT0(?) | 270.003
2 x Steel Assembly | RIGID_FRAME | 0.9 | +6.559 | +6.670 | 4/H | AT0(?) | 270.003
2 x Steel Assembly | RIGID_FRAME | 0.9 | +6.559 | +6.670 | 3/H | AT0(?) | 270.003
2 x Steel Assembly | RIGID_FRAME | 0.9 | +6.559 | +6.670 | 2/H | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 0.9 | +0.000 | +0.054 | 2/A-B | CO0(?) | 54
2 x Steel Assembly | RIGID_FRAME | 0.9 | +0.000 | +0.054 | 3/A | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 0.9 | +0.000 | +0.054 | 4/A-B | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 0.9 | +0.000 | +0.054 | 2/K-L | CO0(?) | 54
2 x Steel Assembly | RIGID_FRAME | 0.9 | +0.000 | +0.054 | 3/L | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 0.9 | +0.000 | +0.054 | 4/K-L | CO0(?) | 54
2 x Steel Assembly | RIGID_FRAME | 0.9 | +0.000 | +0.054 | 1/L | CO0(?) | 54
2 x Steel Assembly | RIGID_FRAME | 0.9 | +0.000 | +0.054 | 5/L | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 0.9 | +0.000 | +0.054 | 1/<A | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 0.9 | +0.000 | +0.054 | 5/<A | CO0(?) | 54
2 x Steel Assembly | RIGID_FRAME | 0.9 | +0.000 | +0.054 | 1/A | CO0(?) | 54
2 x Steel Assembly | RIGID_FRAME | 0.9 | +0.000 | +0.054 | 5/A | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 2.1 | +6.275 | +6.498 | 1/D | G0(?) | 4
Steel Assembly | RIGID_FRAME | 2.8 | +6.162 | +6.671 | 1/D | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.1 | +6.275 | +6.498 | 1/H | G0(?) | 4
Steel Assembly | RIGID_FRAME | 2.8 | +6.162 | +6.671 | 1/H | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +6.223 | +6.732 | 5/D | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.1 | +6.275 | +6.498 | 5/D | G0(?) | 4
Steel Assembly | RIGID_FRAME | 2.8 | +6.162 | +6.671 | 5/D | A0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +2.632 | +2.679 | 5/L | AT0(?) | 170.003
Steel Assembly | RIGID_FRAME | 1.3 | +0.132 | +0.179 | 5/L | AT0(?) | 170.003
Steel Assembly | RIGID_FRAME | 1.3 | +2.632 | +2.679 | 1/L | AT0(?) | 170.003
Steel Assembly | RIGID_FRAME | 1.3 | +0.132 | +0.179 | 1/L | AT0(?) | 170.003
2 x Steel Assembly | RIGID_FRAME | 1.3 | +5.209 | +5.256 | 3/L | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 1.3 | +5.209 | +5.256 | 4/L | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 28.3 | +5.256 | +5.356 | 3-4/L | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 28.3 | +2.679 | +2.779 | 3-4/L | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 28.3 | +0.179 | +0.279 | 3-4/L | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +5.209 | +5.256 | 1/L | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 1.3 | +5.209 | +5.256 | 2/L | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 27.7 | +5.256 | +5.356 | 1-2/L | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.7 | +2.679 | +2.779 | 1-2/L | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.7 | +0.179 | +0.279 | 1-2/L | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.9 | +0.000 | +0.054 | 2/L | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 27.1 | +0.179 | +0.279 | 2-3/L | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +2.679 | +2.779 | 2-3/L | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +5.256 | +5.356 | 2-3/L | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.9 | +0.000 | +0.054 | 4/L | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 1.3 | +5.209 | +5.256 | 5/L | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 27.1 | +0.179 | +0.279 | 4-5/L | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +2.679 | +2.779 | 4-5/L | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +5.256 | +5.356 | 4-5/L | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 23.4 | +4.704 | +5.698 | 2/A-B | G0(?) | 4
Steel Assembly | RIGID_FRAME | 23.4 | +4.704 | +5.698 | 4/A-B | G0(?) | 4
2 x Steel Assembly | RIGID_FRAME | 4.5 | +5.926 | +6.732 | 4/D | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +5.926 | +6.732 | 2/D | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +5.548 | +6.354 | 4/C | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +5.182 | +5.988 | 4/B | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +5.548 | +6.354 | 2/C | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +5.182 | +5.988 | 2/B | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +5.350 | +6.171 | 4/B-C | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +6.238 | +7.059 | 4/E-F | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +5.700 | +6.521 | 4/C-D | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +5.030 | +5.851 | 4/A-B | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +4.909 | +5.730 | 4/A-B | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +6.238 | +7.059 | 2/E-F | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +5.700 | +6.521 | 2/C-D | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +5.030 | +5.851 | 2/A-B | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +4.909 | +5.730 | 2/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 4.5 | +5.350 | +6.171 | 2/B-C | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 1.3 | +6.905 | +7.109 | 4/F | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 1.3 | +6.905 | +7.109 | 3/F | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 1.3 | +6.905 | +7.109 | 2/F | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 28.3 | +6.889 | +7.102 | 3-4/F | PA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 27.7 | +6.889 | +7.102 | 1-2/F | PA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 27.1 | +6.889 | +7.102 | 2-3/F | PA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 27.1 | +6.889 | +7.102 | 4-5/F | PA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +6.124 | +6.732 | 3/D | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +6.223 | +6.732 | 1/D | A0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +1.179 | +1.379 | 1/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +3.579 | +3.779 | 1/A-B | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +2.579 | +2.679 | 2/A-B | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +0.079 | +0.179 | 2/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 4.5 | +4.679 | +4.879 | 2/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 4.5 | +1.179 | +1.379 | 2/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 4.5 | +3.579 | +3.779 | 2/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 0.9 | +2.679 | +2.722 | 2/A | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 0.9 | +0.179 | +0.222 | 2/A | AT0(?) | 270.003
2 x Steel Assembly | RIGID_FRAME | 4.5 | +2.579 | +2.679 | 4/A-B | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 4.5 | +0.079 | +0.179 | 4/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 4.5 | +4.679 | +4.879 | 4/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 4.5 | +1.179 | +1.379 | 4/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 4.5 | +3.579 | +3.779 | 4/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +1.179 | +1.379 | 5/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +3.579 | +3.779 | 5/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.479 | +5.988 | 5/B | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.845 | +6.354 | 5/C | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 1.3 | +6.905 | +7.109 | 5/F | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +5.398 | +5.603 | 5/A | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 1.3 | +5.398 | +5.603 | 4/A | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 1.3 | +5.398 | +5.603 | 3/A | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.746 | +6.354 | 3/C | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.380 | +5.988 | 3/B | A0(?) | 100
Steel Assembly | RIGID_FRAME | 0.9 | +5.438 | +5.549 | 4/A | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 0.9 | +5.438 | +5.549 | 3/A | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 0.9 | +5.438 | +5.549 | 2/A | AT0(?) | 270.003
